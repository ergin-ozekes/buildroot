## package/ardupilot/Config.in
```kconfig
config BR2_PACKAGE_ARDUPILOT
	bool "ardupilot"
	default y
	help
		ArduPilot
		
		http://ardupilot.org
```
